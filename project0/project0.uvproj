# Keil uVision project project0.uvproj, settings and files
target project0 (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: project0
  AfterMake: fromelf --bin --output .\rvmdk\project0.bin .\rvmdk\project0.axf
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RB1
  c misc: --c99
  c include: .;..;..\..\..\..;..\;..\inc;.\utils\;.\third_party\;.\third_party\lwip\src\include;.\third_party\lwip\src\include\ipv4;.\third_party\lwip\ports\tiva-tm4c129\include;.\third_party\lwip\apps
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: project0.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project0.c startup_rvmdk.S uartstdio.c uartstdio.h dispctl.c dispctl.h hal.c hal.h inet.c inet.h
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group 3rd Party
    ./: ustdlib.c lwiplib.c lwipopts.h
    ./third_party/lwip/apps/httpserver_raw/: httpd.c fs.c
